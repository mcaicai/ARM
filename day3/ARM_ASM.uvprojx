# Keil uVision project ARM_ASM.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ARM_ASM +hex
  group Source Group 1
    ./: arm_asm.s
